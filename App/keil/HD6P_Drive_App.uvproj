# Keil uVision project HD6P_Drive_App.uvproj, settings and files
target Target_sw (ARM-ADS)
  device: LPC2134 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: test +hex
  c flags: Optim=1 wLevel=2
  c define: __DEBUG_FLASH
  c include: ..\src\hd_include
  asm define: __DEBUG_FLASH
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: ..\src\mem_c.scf
  link misc: --entry 0x00000000
  group sw_pos
    ../src/: sp_disp.h sp_consume.h main.c sp_info.h sp_cardoper.c rfmod.c sp_consume.c sp_pubfunc.c sp_pubfunc.h sp_flash_impl.c sp_flash_impl.h sp_disp.c sp_transfer.h sp_transfer.c sp_syscontrol.c sp_syscontrol.h
    ../../: HD6P_Lib.lib
    D:/Penn/06work/00Ecard/11hardware/汇多new/amasspos/App/src/: sp_flash_store.c sp_menu.c sp_communicate.c sp_communicate.h
